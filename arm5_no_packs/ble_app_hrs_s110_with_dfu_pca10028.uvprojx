# Keil uVision project ble_app_hrs_s110_with_dfu_pca10028.uvprojx, settings and files
target nrf51422_xxac_s110 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.15.2
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac_s110 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: BLE_DFU_APP_SUPPORT BLE_STACK_SUPPORT_REQD S110 BOARD_PCA10028 SOFTDEVICE_PRESENT NRF51 SWI_DISABLE0 SPI_MASTER_1_ENABLE DEBUG BSP_SIMPLE ENABLE_DEBUG_LOG_SUPPORT
  c misc: --c99
  c include: ..\config;..\components\softdevice\s110\headers;..\bsp;..\components\ble\common;..\components\ble\ble_advertising;..\components\ble\ble_services\ble_dfu;..\components\ble\ble_services\ble_nus;..\components\ble\device_manager;..\components\libraries\util;..\components\libraries\timer;..\components\libraries\trace;..\components\libraries\bootloader_dfu;..\components\libraries\uart;..\components\drivers_nrf\common;..\components\drivers_nrf\hal;..\components\drivers_nrf\pstorage;..\components\drivers_nrf\uart;..\components\drivers_nrf\gpiote;..\components\softdevice\common\softdevice_handler;..\components\toolchain;..\components\device;..\components\drivers_nrf\spi_master;..\usr\inc;..\components\libraries\gpiote;..\components\libraries\pwm;..\components\drivers_nrf\ppi;..\components\drivers_nrf\timer
  asm define: BLE_DFU_APP_SUPPORT BLE_STACK_SUPPORT_REQD S110 BOARD_PCA10028 SOFTDEVICE_PRESENT NRF51 SWI_DISABLE0
  library: MicroLIB
  memory RVCT4: ROM 0x18000 size 0x24000
  memory RVCT9: RAM 0x20002000 size 0x6000
  group Application
    ../usr/src/: main.c event.c calender.c queue.c battery.c pwm.c adc.c led.c button.c Tilt.c
  group Board Support
    ../usr/src/: lis3dh_driver.c
  group nRF_BLE
    ../components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
    ../components/ble/ble_advertising/: ble_advertising.c
    ../components/ble/ble_services/ble_dfu/: ble_dfu.c
    ../components/ble/ble_services/ble_nus/: ble_nus.c
    ../components/ble/device_manager/: device_manager_peripheral.c
  group nRF_Drivers
    ../components/drivers_nrf/uart/: app_uart.c
    ../components/drivers_nrf/hal/: nrf_delay.c
    ../components/drivers_nrf/common/: nrf_drv_common.c
    ../components/drivers_nrf/pstorage/: pstorage.c
    ../components/drivers_nrf/spi_master/: spi_master.c
    ../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../components/drivers_nrf/ppi/: nrf_drv_ppi.c
    ../components/drivers_nrf/timer/: nrf_drv_timer.c
  group nRF_Libraries
    ../components/libraries/util/: app_error.c nrf_assert.c
    ../components/libraries/pwm/: app_pwm.c
    ../components/libraries/trace/: app_trace.c
    ../components/libraries/timer/: app_timer.c
    ../components/libraries/bootloader_dfu/: bootloader_util.c dfu_app_handler.c
    ../components/libraries/uart/: retarget.c
    ../components/libraries/gpiote/: app_gpiote.c
  group nRF_SoftDevice
    ../components/softdevice/common/softdevice_handler/: softdevice_handler.c
target flash_softdevice (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.15.2
  cpu: as above
  output: s110_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1
  c define: BLE_STACK_SUPPORT_REQD
  c misc: --c99
  c include: ..\..\..\config
  asm define: BLE_STACK_SUPPORT_REQD
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
software components: CMSIS:CORE 3.40.0, Device:Startup 7.2.1
